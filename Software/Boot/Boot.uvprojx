# Keil uVision project Boot.uvprojx, settings and files
target Boot (6160000::V6.16::ARMCLANG)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BASELink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER
  c include: .\Code\Sys;.\Code\Bsp;.\Code\Device;.\Code\Lib\inc;.\Code\Lib\CMSIS;.\Code\Middlewares\CherryRB;.\Code\Middlewares\usbd_class\cdc;.\Code\Middlewares\usbd_drivers\inc;.\Code\Func;.\Code\IAP
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Sys
    ./Code/Sys/: startup_at32f403a_407.s system_at32f403a_407.c main.c
  group Bsp
    ./Code/Bsp/: flashx.c timerx.c usb.c
  group Lib
    ./Code/Lib/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_crm.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c
  group IAP
    ./Code/IAP/: iap.c modem.c utils.c
  group Usbd_Class
    ./Code/Middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
    ./Code/Middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group CherryRB
    ./Code/Middlewares/CherryRB/: chry_ringbuffer.c
