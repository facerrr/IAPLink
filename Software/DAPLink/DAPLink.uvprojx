# Keil uVision project DAPLink.uvprojx, settings and files
target DAPLink (6160000::V6.16::ARMCLANG)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DAPLink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER
  c include: .\Code\Sys;.\Code\Bsp;.\Code\Device;.\Code\CherryDAP\DAP;.\Code\CherryDAP\DAP\Include;.\Code\CherryRB;.\Code\CherryUSB\class\cdc;.\Code\CherryUSB\common;.\Code\CherryUSB\core;.\Code\Crc;.\Code\Eeprom;.\Code\SwdHost;.\Code\Lib\inc;.\Code\Lib\CMSIS;.\Code\CherryDAP;.\Code\EasyUi
  memory RVCT4: ROM 0x800c800 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Sys
    ./Code/Sys/: main.c config.c system_at32f403a_407.c startup_at32f403a_407.s
  group Bsp
    ./Code/Bsp/: flashx.c adcx.c timerx.c spix.c
  group Lib
    ./Code/Lib/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_wdt.c
  group Device
    ./Code/Device/: drv_led.c drv_usb.c drv_usb2uart.c user_param.c key.c
  group CherryUSB
    ./Code/CherryUSB/port/dwc2/: usb_glue_at.c
    ./Code/CherryUSB/port/fsdev/: usb_dc_fsdev.c
    ./Code/CherryUSB/core/: usbd_core.c
    ./Code/CherryUSB/class/cdc/: usbd_cdc.c
  group CherryDAP
    ./Code/CherryDAP/: dap_descriptors.c dap_main.c
  group CherryRB
    ./Code/CherryRB/: chry_ringbuffer.c
  group SwdHost
    ./Code/SwdHost/: swd_host.c target.c target_flash.c
  group DAP
    ./Code/CherryDAP/DAP/Source/: DAP.c DAP_vendor.c SW_DP.c
  group Eeprom
    ./Code/Eeprom/: eeprom.c
  group Crc
    ./Code/Crc/: mbcrc.c
  group EasyUI
    ./Code/EasyUi/: easy_ui.c font.c function.c ips096.c profile_photo_erbws.c
