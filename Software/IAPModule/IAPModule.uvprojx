# Keil uVision project IAPModule.uvprojx, settings and files
target IAPModule (6160000::V6.16::ARMCLANG)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IAPModule
  AfterMake: fromelf --bin --output Objects\IAPModule.bin Objects\IAPModule.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER
  c misc: -Wno-invalid-source-encoding
  c include: .\Code\Sys;.\Code\Bsp;.\Code\Lib\CMSIS;.\Code\Lib\inc;.\Code\Device;.\Code\IAP;.\Code\Middlewares\usbd_class\cdc;.\Code\Middlewares\usbd_drivers\inc;.\Code\Middlewares\CherryRB;.\Code\EasyUi;.\Code\LCD
  memory RVCT4: ROM 0x8025800 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Sys
    ./Code/Sys/: system_at32f403a_407.c startup_at32f403a_407.s main.c
  group Bsp
    ./Code/Bsp/: adcx.c timerx.c uartx.c flashx.c usb.c spix.c
  group Lib
    ./Code/Lib/src/: at32f403a_407_adc.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_wdt.c at32f403a_407_acc.c at32f403a_407_usb.c at32f403a_407_spi.c
  group Device
    ./Code/Device/: key.c led.c
  group IAP
    ./Code/IAP/: iap.c recv.c modem.c
  group Usbd_Class
    ./Code/Middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
    ./Code/Middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group CherryRB
    ./Code/Middlewares/CherryRB/: chry_ringbuffer.c
  group EasyUI
    ./Code/EasyUi/: easy_ui.c font.c function.c menu.c profile_photo_erbws.c ipsCommon.c
